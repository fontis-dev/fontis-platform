# Fontis wpa_supplicant: WiFi client with WPA3 support

PACKAGECONFIG:append = " openssl"
