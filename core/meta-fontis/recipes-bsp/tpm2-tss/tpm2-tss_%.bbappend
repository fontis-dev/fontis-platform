# Fontis TPM2 configuration: enable all features for measured boot and key sealing

PACKAGECONFIG:append = " fapi esys"
