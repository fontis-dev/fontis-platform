# wlroots compositor config for Fontis: DRM/KMS, libinput, GPU acceleration

PACKAGECONFIG:append = " drm-backend libinput gles2"
