# Wayland configuration for Fontis: protocols for compositor and module surfaces

PACKAGECONFIG:append = " "
